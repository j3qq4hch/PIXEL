# IAR project usbd_virtualcomport.ewp, settings and files
configuration STM32072B-EVAL (ARM, debug)
  General.OGChipSelectEditMenu: STM32F030x6 ST STM32F030x6
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  General.CoreVariant: 34
  General.FPU2: 0
  ICCARM.CCDefines: USE_STDPERIPH_DRIVER
  ICCARM.CCIncludePath2: ..\; ..\inc; ..\..\Libraries\CMSIS\Device\ST\STM32F0xx\Include; ..\..\Libraries\STM32F0xx_StdPeriph_Driver\inc; ..\..\FreeRTOS\include; ..\..\FreeRTOS\portable
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  AARM.AUserIncludes: ..\; ..\inc
  OBJCOPY.OOCOutputFile: STM32072B-EVAL_usbd_virtualcomport.hex
  ILINK.IlinkOutputFile: STM32072B-EVAL_USBD.out
  ILINK.IlinkIcfFile: stm32f042F4_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group App
    ../src/: bsp.c main.c settings.c stm32_it.c
    ../inc/: FreeRTOSConfig.h
  group FreeRTOS
    ../../FreeRTOS/: croutine.c event_groups.c list.c queue.c tasks.c timers.c
  group FreeRTOS/portable
    ../../FreeRTOS/portable/: heap_1.c port.c portasm.s portmacro.h
  group STM32F0XX
    ../../Libraries/CMSIS/Device/ST/STM32F0xx/Source/Templates/iar/: startup_stm32f030.s
    ../src/: system_stm32f0xx.c
  group STM32F0xx_StdPeriph_Driver
    ../../Libraries/STM32F0xx_StdPeriph_Driver/src/: stm32f0xx_adc.c stm32f0xx_crc.c stm32f0xx_crs.c stm32f0xx_dbgmcu.c stm32f0xx_dma.c stm32f0xx_exti.c stm32f0xx_flash.c stm32f0xx_gpio.c stm32f0xx_i2c.c stm32f0xx_misc.c stm32f0xx_pwr.c stm32f0xx_rcc.c stm32f0xx_syscfg.c stm32f0xx_tim.c stm32f0xx_usart.c
